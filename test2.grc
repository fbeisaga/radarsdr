options:
  parameters:
    author: root
    generate_options: qt_gui
    id: test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: max_output_buffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: min_output_buffer
  id: variable
  parameters:
    value: int(packet_len*2)
  states: {}
- name: num_delay_samp
  id: variable_qtgui_range
  parameters:
    label: Number of delayed samples
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: packet_len
    value: '0'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2**8
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: send_samp
  id: variable
  parameters:
    value: 100,400,300
  states: {}
- name: wait_samp
  id: variable
  parameters:
    value: 100,100,100,100
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: radar_signal_generator_sync_pulse_c_0_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_output_buffer
    packet_len: packet_len
    pulse_amplitude: '0.5'
    pulse_len: send_samp
    pulse_pause: wait_samp
  states: {}

connections:
- [radar_signal_generator_sync_pulse_c_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
