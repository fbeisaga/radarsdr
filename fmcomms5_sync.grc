options:
  parameters:
    author: root
    generate_options: qt_gui
    id: fmcomss5_sync
    output_language: python
    title: fmcomss5_sync
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '1000000000'
  states: {}
- name: min_output_buffer
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: num_corr
  id: variable_qtgui_range
  parameters:
    label: Number of cross correlations
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: packet_len
    value: packet_len
  states: {}
- name: num_delay_samp
  id: variable_qtgui_range
  parameters:
    label: Number of delayed samples
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: packet_len
    value: '1200'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: sum(wait_samp)+sum(send_samp)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000000'
  states: {}
- name: send_samp
  id: variable
  parameters:
    value: 100,400,300
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    orient: Qt.Horizontal
    start: '-50'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: wait_samp
  id: variable
  parameters:
    value: 100,100,100,100
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(num_delay_samp)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: complex
  states: {}
- name: iio_fmcomms5_sink_0
  id: iio_fmcomms5_sink
  parameters:
    attenuation1: tx_gain
    attenuation2: '10.0'
    attenuation3: '10.0'
    attenuation4: '0'
    bandwidth: '20000000'
    buffer_size: '2400'
    cyclic: 'False'
    filter: ''
    frequency1: int(center_freq)
    frequency2: int(center_freq)
    rf_port_select: '''A'''
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'False'
    tx3_en: 'False'
    tx4_en: 'False'
    uri: 'local:'
  states: {}
- name: iio_fmcomms5_source_0
  id: iio_fmcomms5_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'False'
    buffer_size: '4800'
    filter: ''
    frequency1: int(center_freq)
    frequency2: int(center_freq)
    gain1: '''manual'''
    gain2: '''fast_attack'''
    gain3: '''manual'''
    gain4: '''fast_attack'''
    manual_gain1: '64'
    manual_gain2: '64'
    manual_gain3: '64'
    manual_gain4: '64'
    minoutbuf: min_output_buffer
    quadrature: 'False'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'False'
    rx1_en: 'True'
    rx2_en: 'False'
    rx3_en: 'False'
    rx4_en: 'False'
    samplerate: samp_rate
    uri: 'local:'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: QT GUI Plot
    nconnections: '2'
    size: packet_len*4
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: radar_estimator_sync_pulse_c_0
  id: radar_estimator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    num_xcorr: int(num_corr)
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_signal_generator_sync_pulse_c_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_output_buffer
    packet_len: packet_len
    pulse_amplitude: '0.5'
    pulse_len: send_samp
    pulse_pause: wait_samp
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''J1'''
    antenna_tx: '''J1'''
    args_rx: ''
    args_tx: ''
    center_freq: center_freq
    gain_rx: rx_gain
    gain_tx: tx_gain
    minoutbuf: min_output_buffer
    num_delay_samps: int(num_delay_samp)
    samp_rate: samp_rate
    timeout_rx: '0.2'
    timeout_tx: '0.2'
    wait_rx: wait_to_start
    wait_tx: wait_to_start
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_complex_to_mag_squared_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', radar_estimator_sync_pulse_c_0, '1']
- [iio_fmcomms5_source_0, '0', blocks_delay_0, '0']
- [radar_estimator_sync_pulse_c_0, Msg out, radar_print_results_0, Msg in]
- [radar_signal_generator_sync_pulse_c_0, '0', blocks_complex_to_mag_squared_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', iio_fmcomms5_sink_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', radar_estimator_sync_pulse_c_0, '0']

metadata:
  file_format: 1
