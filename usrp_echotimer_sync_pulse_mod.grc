options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_echotimer_sync_pulse_mod
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '1000000000'
  states: {}
- name: min_output_buffer
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: num_corr
  id: variable_qtgui_range
  parameters:
    label: Number of cross correlations
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: packet_len
    value: packet_len
  states: {}
- name: num_delay_samp
  id: variable_qtgui_range
  parameters:
    label: Number of delayed samples
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: packet_len
    value: '0'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: sum(wait_samp)+sum(send_samp)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: send_samp
  id: variable
  parameters:
    value: 100,400,300
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: wait_samp
  id: variable
  parameters:
    value: 100,100,100,100
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    label2: ''
    name: QT GUI Plot
    nconnections: '2'
    size: packet_len*4
    srate: samp_rate
    type: float
  states: {}
- name: radar_estimator_sync_pulse_c_0
  id: radar_estimator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    num_xcorr: int(num_corr)
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_signal_generator_sync_pulse_c_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_output_buffer
    packet_len: packet_len
    pulse_amplitude: '0.5'
    pulse_len: send_samp
    pulse_pause: wait_samp
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''RX2'''
    antenna_tx: '''TX/RX'''
    args_rx: '""'
    args_tx: '""'
    center_freq: center_freq
    clock_source_rx: '''internal'''
    gain_rx: rx_gain
    gain_tx: tx_gain
    minoutbuf: min_output_buffer
    num_delay_samps: int(num_delay_samp)
    samp_rate: samp_rate
    time_source_rx: '''none'''
    timeout_rx: '0.2'
    timeout_tx: '0.2'
    wait_rx: wait_to_start
    wait_tx: wait_to_start
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '''J1'''
    center_freq0: 2.4e9
    clock_rate: '0.0'
    dev_addr: '''addr=192.168.10.6'''
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: '''packet_len'''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    clock_source0: internal
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '''J1'''
    center_freq0: 2.4e9
    clock_rate: '0.0'
    clock_source0: mimo
    dev_addr: '''addr=192.168.10.4'''
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    time_source0: mimo
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    clock_source0: internal
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_mag_0_0, '0']
- [analog_sig_source_x_0, '0', radar_estimator_sync_pulse_c_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', radar_estimator_sync_pulse_c_0, '1']
- [radar_estimator_sync_pulse_c_0, Msg out, radar_print_results_0, Msg in]
- [radar_signal_generator_sync_pulse_c_0, '0', blocks_complex_to_mag_0_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', radar_estimator_sync_pulse_c_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', radar_usrp_echotimer_cc_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', uhd_usrp_sink_0, command]
- [radar_signal_generator_sync_pulse_c_0, '0', uhd_usrp_sink_1, '0']
- [radar_usrp_echotimer_cc_0, '0', blocks_complex_to_mag_0, '0']
- [radar_usrp_echotimer_cc_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [radar_usrp_echotimer_cc_0, '0', radar_estimator_sync_pulse_c_0, '1']
- [uhd_usrp_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [uhd_usrp_source_1, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_1, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
