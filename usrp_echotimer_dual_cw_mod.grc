options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_echotimer_dual_cw_mod
    output_language: python
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**10
  states: {}
- name: delay_samp
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0
    label: Number delay samples
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '28'
  states: {}
- name: freq
  id: variable
  parameters:
    value: (-3000000,3000000)
  states: {}
- name: freq_res
  id: variable
  parameters:
    value: samp_rate/float(packet_len)
  states: {}
- name: gain_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: RX gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {state: disabled}
- name: gain_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: TX gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {state: disabled}
- name: max_output_buffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: min_output_buffer
  id: variable
  parameters:
    value: int(packet_len*2)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2**21
  states: {}
- name: range_add
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1
    label: Add range
    outputmsgname: value
    showports: 'False'
    start: '-range_res'
    step: '0.1'
    stop: range_res
    value: '-1'
  states: {}
- name: range_res
  id: variable
  parameters:
    value: 3e8/2/float((freq[1]-freq[0]))
  states: {}
- name: range_time
  id: variable
  parameters:
    value: '30'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: RX Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: samp_protect
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1
    label: Find peak protected samples
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: Find peak threshold
    outputmsgname: value
    showports: 'False'
    start: '-200'
    step: '1'
    stop: '100'
    value: '-50'
  states: {}
- name: time_res
  id: variable
  parameters:
    value: packet_len/float(samp_rate)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: TX Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: v_res
  id: variable
  parameters:
    value: freq_res*3e8/2/center_freq
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/float(decim_fac)
    lengthtagname: '"packet_len"'
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/float(decim_fac)
    lengthtagname: '"packet_len"'
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: packet_len//decim_fac
    gui_hint: tabs@0
    label2: ''
    name: QT GUI Plot
    nconnections: '2'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@1
    label1: ''
    label2: ''
    name: QT GUI Plot
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: radar_estimator_fsk_0
  id: radar_estimator_fsk
  parameters:
    center_freq: center_freq
    delta_freq: (freq[1]-freq[0])
    push_power: 'False'
  states: {}
- name: radar_find_max_peak_c_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'True'
    len_key: '"packet_len"'
    max_freq: (-300,300)
    samp_protect: int(samp_protect)
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {}
- name: radar_msg_manipulator_0
  id: radar_msg_manipulator
  parameters:
    const_add: range_add
    const_mult: '1'
    symbols: ('range',)
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_qtgui_time_plot_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '[0,range_res]'
    interval: '100'
    label_y: '''range'''
    range_time: range_time
  states: {}
- name: radar_qtgui_time_plot_1
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '[-3,3]'
    interval: '100'
    label_y: '''velocity'''
    range_time: range_time
  states: {}
- name: radar_signal_generator_cw_c_0
  id: radar_signal_generator_cw_c
  parameters:
    amplitude: amplitude
    frequency: freq[0]
    len_key: '"packet_len"'
    maxoutbuf: max_output_buffer
    minoutbuf: min_output_buffer
    packet_len: packet_len
    samp_rate: samp_rate
  states: {}
- name: radar_signal_generator_cw_c_0_0
  id: radar_signal_generator_cw_c
  parameters:
    amplitude: amplitude
    frequency: freq[1]
    len_key: '"packet_len"'
    maxoutbuf: max_output_buffer
    minoutbuf: min_output_buffer
    packet_len: packet_len
    samp_rate: samp_rate
  states: {}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    minoutbuf: min_output_buffer
    packet_len: packet_len//decim_fac
  states: {}
- name: radar_ts_fft_cc_0_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    minoutbuf: min_output_buffer
    packet_len: packet_len//decim_fac
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''J1'''
    antenna_tx: '''J1'''
    args_rx: '''addr=192.168.10.6'''
    args_tx: '''addr=192.168.10.4'''
    center_freq: center_freq
    gain_rx: gain_rx
    gain_tx: gain_tx
    minoutbuf: min_output_buffer
    num_delay_samps: int(delay_samp)
    samp_rate: samp_rate
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: radar
    label1: debug
    num_tabs: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_xx_1, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_add_xx_1, '0', radar_usrp_echotimer_cc_0, '0']
- [blocks_add_xx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', radar_find_max_peak_c_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_ts_fft_cc_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', radar_ts_fft_cc_0_0, '0']
- [radar_estimator_fsk_0, Msg out, radar_msg_manipulator_0, Msg in]
- [radar_find_max_peak_c_0, Msg out, radar_estimator_fsk_0, Msg in]
- [radar_msg_manipulator_0, Msg out, radar_print_results_0, Msg in]
- [radar_msg_manipulator_0, Msg out, radar_qtgui_time_plot_0, Msg in]
- [radar_msg_manipulator_0, Msg out, radar_qtgui_time_plot_1, Msg in]
- [radar_signal_generator_cw_c_0, '0', blocks_add_xx_1, '0']
- [radar_signal_generator_cw_c_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [radar_signal_generator_cw_c_0_0, '0', blocks_add_xx_1, '1']
- [radar_signal_generator_cw_c_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [radar_ts_fft_cc_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [radar_ts_fft_cc_0_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [radar_usrp_echotimer_cc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [radar_usrp_echotimer_cc_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
