options:
  parameters:
    author: root
    generate_options: qt_gui
    id: RADAR_CW_FMCOMM5_V4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: attenuation
  id: variable_qtgui_range
  parameters:
    label: attenuation(TX)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '80'
    value: '10'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**8
  states: {}
- name: freq
  id: variable
  parameters:
    value: (-6000000,6000000)
  states: {}
- name: freq_res
  id: variable
  parameters:
    value: samp_rate/float(packet_len)
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain(RX)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '80'
    value: '50'
  states: {}
- name: max_output_buffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: min_output_buffer
  id: variable
  parameters:
    value: int(packet_len*2)
  states: {}
- name: mult
  id: variable_qtgui_range
  parameters:
    label: mult
    orient: Qt.Horizontal
    start: '-10'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2**17
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    label: phase
    orient: Qt.Horizontal
    start: '-10'
    step: '0.01'
    stop: '10'
    value: '0'
  states: {}
- name: range_res
  id: variable
  parameters:
    value: 3e8/2/float((freq[1]-freq[0]))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: threshold
    orient: Qt.Horizontal
    start: '-300'
    step: '5'
    stop: '-10'
    value: '-15'
  states: {}
- name: time_res
  id: variable
  parameters:
    value: packet_len/float(samp_rate)
  states: {}
- name: v_res
  id: variable
  parameters:
    value: freq_res*3e8/2/center_freq
  states: {}
- name: value_range
  id: variable_qtgui_range
  parameters:
    label: range
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: vel
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-50'
    step: '0.1'
    stop: '50'
    value: '50'
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_output_buffer
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/float(decim_fac)
    lengthtagname: '"packet_len"'
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/float(decim_fac)
    lengthtagname: '"packet_len"'
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: iio_attr_sink_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: ad9361-phy
    output: 'False'
    required_enable: 'False'
    uri: 'local:'
  states: {}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    update_interval_ms: '3000'
    value: str(gain)
  states: {}
- name: iio_fmcomms5_sink_0
  id: iio_fmcomms5_sink
  parameters:
    attenuation1: attenuation
    attenuation2: '10.0'
    attenuation3: '10.0'
    attenuation4: '0'
    bandwidth: samp_rate
    buffer_size: 2**14
    cyclic: 'False'
    filter: ''
    frequency1: int(center_freq)
    frequency2: int(center_freq)
    rf_port_select: '''A'''
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'False'
    tx3_en: 'False'
    tx4_en: 'False'
    uri: 'local:'
  states: {}
- name: iio_fmcomms5_source_0
  id: iio_fmcomms5_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: 2**14
    filter: ''
    frequency1: int(center_freq)
    frequency2: int(center_freq)
    gain1: '''manual'''
    gain2: '''fast_attack'''
    gain3: '''manual'''
    gain4: '''fast_attack'''
    manual_gain1: '64'
    manual_gain2: '64'
    manual_gain3: '64'
    manual_gain4: '64'
    maxoutbuf: max_output_buffer
    minoutbuf: min_output_buffer
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    rx3_en: 'False'
    rx4_en: 'False'
    samplerate: samp_rate
    uri: 'local:'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '2450000000'
    fftsize: packet_len//decim_fac
    label1: TX_signal
    label2: RX_signal
    name: QT GUI Plot
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: packet_len//decim_fac
    label2: ''
    label3: ''
    name: QT GUI Plot
    nconnections: '3'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: radar_estimator_fsk_0
  id: radar_estimator_fsk
  parameters:
    center_freq: center_freq
    delta_freq: (freq[1]-freq[0])
    push_power: 'False'
  states: {}
- name: radar_find_max_peak_c_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'True'
    len_key: '"packet_len"'
    max_freq: '[-300,300]'
    samp_protect: '0'
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {}
- name: radar_msg_manipulator_0
  id: radar_msg_manipulator
  parameters:
    const_add: phase
    const_mult: mult
    symbols: '''range'''
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_qtgui_time_plot_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '[0,range_res]'
    interval: '1000'
    label_y: '''range'''
    range_time: '20'
  states: {}
- name: radar_qtgui_time_plot_0_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '[-15,15]'
    interval: '100'
    label_y: '''velocity'''
    range_time: '60'
  states: {state: disabled}
- name: radar_qtgui_time_plot_0_0_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '[-15,15]'
    interval: '100'
    label: VELOCITY TRACCKING
    label_y: '''velocity'''
    range_time: '60'
  states: {state: disabled}
- name: radar_qtgui_time_plot_0_1
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '[0,12.5]'
    interval: '100'
    label: RANGE TRACCKING
    label_y: '''range'''
    range_time: '60'
  states: {state: disabled}
- name: radar_signal_generator_cw_c_0
  id: radar_signal_generator_cw_c
  parameters:
    amplitude: '0.5'
    frequency: freq[0]
    len_key: '"packet_len"'
    maxoutbuf: max_output_buffer
    minoutbuf: min_output_buffer
    packet_len: packet_len
    samp_rate: samp_rate
  states: {}
- name: radar_signal_generator_cw_c_0_0
  id: radar_signal_generator_cw_c
  parameters:
    amplitude: '0.5'
    frequency: freq[1]
    len_key: '"packet_len"'
    maxoutbuf: max_output_buffer
    minoutbuf: min_output_buffer
    packet_len: packet_len
    samp_rate: samp_rate
  states: {}
- name: radar_tracking_singletarget_0
  id: radar_tracking_singletarget
  parameters:
    num_particle: '1000'
    std_accel_sys: '500E-3'
    std_range_meas: '3'
    std_velocity_meas: v_res
    threshold_lost: '1'
    threshold_track: '1E-3'
  states: {state: disabled}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    minoutbuf: min_output_buffer
    packet_len: packet_len//decim_fac
  states: {}
- name: radar_ts_fft_cc_0_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    minoutbuf: min_output_buffer
    packet_len: packet_len//decim_fac
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_add_xx_1, '0', iio_fmcomms5_sink_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', qtgui_freq_sink_x_0_0, '2']
- [blocks_multiply_conjugate_cc_1, '0', radar_find_max_peak_c_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_ts_fft_cc_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', radar_ts_fft_cc_0_0, '0']
- [iio_attr_updater_0, out, iio_attr_sink_1, attr]
- [iio_fmcomms5_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [iio_fmcomms5_source_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [iio_fmcomms5_source_0, '0', qtgui_freq_sink_x_0, '1']
- [radar_estimator_fsk_0, Msg out, radar_msg_manipulator_0, Msg in]
- [radar_estimator_fsk_0, Msg out, radar_qtgui_time_plot_0_0, Msg in]
- [radar_estimator_fsk_0, Msg out, radar_tracking_singletarget_0, Msg in]
- [radar_find_max_peak_c_0, Msg out, radar_estimator_fsk_0, Msg in]
- [radar_msg_manipulator_0, Msg out, radar_print_results_0, Msg in]
- [radar_msg_manipulator_0, Msg out, radar_qtgui_time_plot_0, Msg in]
- [radar_signal_generator_cw_c_0, '0', blocks_add_xx_1, '0']
- [radar_signal_generator_cw_c_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [radar_signal_generator_cw_c_0_0, '0', blocks_add_xx_1, '1']
- [radar_signal_generator_cw_c_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [radar_tracking_singletarget_0, Msg out, radar_qtgui_time_plot_0_0_0, Msg in]
- [radar_tracking_singletarget_0, Msg out, radar_qtgui_time_plot_0_1, Msg in]
- [radar_ts_fft_cc_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [radar_ts_fft_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [radar_ts_fft_cc_0_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [radar_ts_fft_cc_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [rational_resampler_xxx_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
